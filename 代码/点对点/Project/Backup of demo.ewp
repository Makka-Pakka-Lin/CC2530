# IAR project Backup of demo.ewp, settings and files
configuration Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\CC2530_lib\basicrf; ..\CC2530_lib\board; ..\CC2530_lib\common; ..\CC2530_lib\utils; ..\CC2530_lib\mylib; ..\CC2530_lib\moudle; ..\sensor_drv
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_CC2530F256_banked.xcl
configuration Release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\
  ICC8051.CCDefines: NDEBUG
  ICC8051.CCOptLevel: 3
  A8051.ADefines: NDEBUG
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\_generic\lnk51ew_8052.xcl
configuration temprh_sensor (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: CC2530_DEBUG
configuration fire_sensor (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: CC2530_DEBUG
configuration collect (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: CC2530_DEBUG
  group app
    ./: collect.c fire_sensor.c temprh_sensor.c
  group BasicRF
    ../CC2530_lib/basicrf/: basic_rf.h basic_rf.r51
  group board
    ../CC2530_lib/board/: hal_adc.c hal_board.c hal_led.c hal_pwm.c
  group common
    ../CC2530_lib/common/: hal_clock.c hal_digio.c hal_int.c hal_mcu.c hal_rf.c hal_rf_security.c hal_rf_util.c hal_sleep.c hal_timer_32k.c hal_uart.c hal_uart1.c
  group MyLib
    ../CC2530_lib/mylib/: TIMER.c UART_PRINT.c UART_SEND_RECV.c
  group SensorDrv
    ../sensor_drv/: get_adc.c get_swsensor.c sh10.c
  group utils
    ../CC2530_lib/utils/: util.c
